# Keil uVision project project.uvproj, settings and files
target Qitas (MCS-51)
  device: CH554 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: USB_PD +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: CLOCK_FREQ_24
  c include: .\include;.\keilc51;..\src
  group user
    ./: usb_ep0.c usb_desc.c usb_it.c usb_endp.c usb_string_desc.c ch554_conf.c main.c bootloader.c delay.c usb_cdc.c usbpd_phy.c
